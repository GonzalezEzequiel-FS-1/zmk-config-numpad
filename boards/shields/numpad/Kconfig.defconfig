## config/boards/shields/numPad/Kconfig.shield
```kconfig
config SHIELD_numPad
    bool "Enable numPad Shield"
    default y if SHIELD_zPad
```
